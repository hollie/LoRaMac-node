# Keil uVision project BootLoader.uvproj, settings and files
target BootLoader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_DEBUGGER
  c include: ..\..\..\src;..\..\..\src\boards\RFM96W-BB;..\..\..\src\boards\RFM96W-BB\cmsis;..\..\..\src\boards\RFM96W-BB\usb\dfu\inc;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32_USB-FS-Device_Driver\inc;..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../src/apps/bootloader/RFM96W-BB/: main.c
  group boards\RFM96W-BB
    ../../../src/boards/RFM96W-BB/: gpio-board.c usb-dfu-board.c
  group boards\RFM96W-BB\cmsis
    ../../../src/boards/RFM96W-BB/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../src/boards/RFM96W-BB/cmsis/: system_stm32l1xx.c
  group boards\RFM96W-BB\usb
    ../../../src/boards/RFM96W-BB/usb/dfu/src/: dfu_mal.c flash_if.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group boards\RFM96W-BB\STM32_USB-FS-Device_Driver
    ../../../src/boards/mcu/stm32/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group boards\RFM96W-BB\STM32L1xx_StdPeriph_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c
  group system
    ../../../src/system/: gpio.c
