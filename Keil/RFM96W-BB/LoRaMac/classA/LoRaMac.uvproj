# Keil uVision project LoRaMac.uvproj, settings and files
target RFM96W-BB-433 (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RFM96W-BB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_433 UNUSE_USB_CDC
  c include: ..\..\..\..\src;..\..\..\..\src\boards\RFM96W-BB;..\..\..\..\src\boards\RFM96W-BB\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\RFM96W-BB\usb\cdc\inc;..\..\..\..\src\boards\mcu\stm32\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../../src/apps/LoRaMac/classA/RFM96W-BB/: main.c
  group boards\RFM96W-BB
    ../../../../src/boards/RFM96W-BB/: board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c timer-board.c uart-board.c usb-support.c
  group boards\RFM96W-BB\cmsis
    ../../../../src/boards/RFM96W-BB/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../../src/boards/RFM96W-BB/cmsis/: system_stm32l1xx.c
  group boards\RFM96W-BB\STM32L1xx_StdPeriph_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: delay.c fifo.c gpio.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
target RFM96W-BB-433-Bootloader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: RFM96W-BB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_433 USE_BOOTLOADER
  c include: ..\..\..\..\src;..\..\..\..\src\boards\RFM96W-BB;..\..\..\..\src\boards\RFM96W-BB\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
target RFM96W-BB-868 (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: RFM96W-BB +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_868
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target RFM96W-BB-868-Bootloader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: RFM96W-BB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_868 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
