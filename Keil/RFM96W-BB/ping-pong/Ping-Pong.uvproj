# Keil uVision project Ping-Pong.uvproj, settings and files
target Ping-Pong-433-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_433 USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards\RFM96W-BB;..\..\..\src\boards\RFM96W-BB\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group apps
    ../../../src/apps/ping-pong/RFM96W-BB/: main.c
  group boards\RFM96W-BB
    ../../../src/boards/RFM96W-BB/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c timer-board.c uart-board.c
  group boards\RFM96W-BB\cmsis
    ../../../src/boards/RFM96W-BB/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../src/boards/RFM96W-BB/cmsis/: system_stm32l1xx.c
  group boards\RFM96W-BB\STM32L1xx_StdPeriph_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
target Ping-Pong-433-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_433 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-433-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_433 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-433-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_433 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-470-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_470 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-470-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_470 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-470-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_470 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-470-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_470 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-868-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-868-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-868-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-868-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-915-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-915-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-915-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-915-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
