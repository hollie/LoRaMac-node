# Keil uVision project LoRaMac.uvproj, settings and files
target LoRaMac (ARM-ADS)
  device: EFM32ZG222F32 Energy Micro
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(24000000) ELITTLE
  output: LoRaMac
  c flags: Optim=2 OneElfS=1
  c define: USE_DEBUGGER LOW_POWER_MODE_ENABLE EFM32ZG222F32
  c misc: --c99
  c include: ..\..\..\..\src;..\..\..\..\src\boards\EFM32-STK3x00;..\..\..\..\src\boards\Bleeper\cmsis;..\..\..\..\src\boards\mcu\efm32;..\..\..\..\src\boards\mcu\efm32\cmsis\Include;..\..\..\..\src\boards\mcu\efm32\emlib\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\mcu\efm32\Device\EnergyMicro\EFM32ZG\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group apps
    ../../../../src/apps/LoRaMac/classA/EFM32-STK3x00/: main.c
  group boards\EFM32-STK3x00
    ../../../../src/boards/EFM32-STK3x00/: board.c gpio-board.c
  group boards\EFM32-STK3200\cmsis
    ../../../../src/boards/EFM32-STK3x00/cmsis/: startup_efm32zg.s system_efm32zg.c
  group boards\EFM32-STK3x00\emlib
    ../../../../src/boards/mcu/efm32/emlib/src/: em_cmu.c em_emu.c em_gpio.c em_i2c.c em_leuart.c em_rmu.c em_rtc.c em_system.c
  group boards\mcu\efm32
    ../../../../src/boards/mcu/efm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: delay.c gpio.c i2c.c timer.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
