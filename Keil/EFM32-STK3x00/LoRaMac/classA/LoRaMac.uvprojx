# Keil uVision project LoRaMac.uvprojx, settings and files
target LoRaMac-STK3200 (ARM-ADS)
  device: EFM32ZG222F32 Energy Micro
  pack: Keil.EFM32ZGxxx_DFP.1.0.1
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(24000000) ELITTLE
  output: LoRaMac-STK3200
  c flags: Optim=1 OneElfS=1
  c define: USE_BAND_868
  c misc: --c99
  c include: ..\..\..\..\src;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\mcu\efm32;..\..\..\..\src\boards\EFM32-STK3x00;..\..\..\..\src\boards\mcu\efm32\emlib\inc;..\..\..\..\src\boards\mcu\efm32\cmsis\Include;..\..\..\..\src\boards\mcu\efm32\Device\EnergyMicro\EFM32ZG\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group apps
    ../../../../src/apps/LoRaMac/classA/EFM32-STK3x00/: main.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: delay.c gpio.c i2c.c timer.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
  group boards\EFM32-STK3200\cmsis
    ../../../../src/boards/EFM32-STK3x00/cmsis/ARM/: startup_efm32zg.s
    ../../../../src/boards/EFM32-STK3x00/cmsis/: system_efm32zg.c
  group boards\EFM32-STK3600\cmsis
    ../../../../src/boards/EFM32-STK3x00/cmsis/: system_efm32lg.c
    ../../../../src/boards/EFM32-STK3x00/cmsis/ARM/: startup_efm32lg.s
  group boards\EFM32-STK3700\cmsis
    ../../../../src/boards/EFM32-STK3x00/cmsis/ARM/: startup_efm32gg.s
    ../../../../src/boards/EFM32-STK3x00/cmsis/: system_efm32gg.c
  group boards\mcu\efm32
    ../../../../src/boards/mcu/efm32/: sysIrqHandlers.c utilities.c
  group boards\EFM32-STK3x00
    ../../../../src/boards/EFM32-STK3x00/: board.c gpio-board.c sx1272-board.c spi-board.c i2c-board.c rtc-board.c timer-board.c
  group boards\EFM32-STK3x00\emlib
    ../../../../src/boards/mcu/efm32/emlib/src/: em_cmu.c em_emu.c em_gpio.c em_i2c.c em_leuart.c em_rmu.c em_rtc.c em_system.c em_usart.c
target LoRaMac-STK3700 (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  pack: Keil.EFM32GGxxx_DFP.2.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRaMac-STK3700
  c flags: Optim=1 OneElfS=1
  c define: USE_BAND_868
  c misc: --c99
  c include: ..\..\..\..\src;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\mcu\efm32;..\..\..\..\src\boards\EFM32-STK3x00;..\..\..\..\src\boards\mcu\efm32\emlib\inc;..\..\..\..\src\boards\mcu\efm32\cmsis\Include;..\..\..\..\src\boards\mcu\efm32\Device\EnergyMicro\EFM32GG\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target LoRaMac-STK3600 (ARM-ADS)
  device: EFM32LG990F256 Energy Micro
  pack: Keil.EFM32LGxxx_DFP.1.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRaMac-STK3600
  c flags: Optim=1 OneElfS=1
  c define: USE_BAND_868
  c misc: --c99
  c include: ..\..\..\..\src;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\mcu\efm32;..\..\..\..\src\boards\EFM32-STK3x00;..\..\..\..\src\boards\mcu\efm32\emlib\inc;..\..\..\..\src\boards\mcu\efm32\cmsis\Include;..\..\..\..\src\boards\mcu\efm32\Device\EnergyMicro\EFM32LG\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
